PACKAGECONFIG_append_romulus = " verify_pnor_signature"
EXTRA_OECONF_append_romulus = " ACTIVE_PNOR_MAX_ALLOWED=1"
