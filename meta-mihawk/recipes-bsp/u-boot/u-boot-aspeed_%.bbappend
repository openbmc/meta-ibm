FILESEXTRAPATHS_prepend_mihawk := "${THISDIR}/${PN}:"
SRC_URI_append_mihawk = " file://0002-board-aspeed-aspeednic-Use-MAC2-for-networking.patch"
