FILESEXTRAPATHS_prepend_mihawk := "${THISDIR}/${PN}:"
