RDEPENDS_${PN}-inventory += "openpower-fru-vpd openpower-occ-control virtual/obmc-gpio-presence"
RDEPENDS_${PN}-extras += "phosphor-webui phosphor-image-signing "

