PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " swift-fan-policy-native"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " swift-thermal-policy-native"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " swift-power-supply-policy-native"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " swift-events-policy-native"
