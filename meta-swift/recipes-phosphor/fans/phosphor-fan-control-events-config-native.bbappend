# TODO Uncomment once the fan configuration has been updated
# FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
