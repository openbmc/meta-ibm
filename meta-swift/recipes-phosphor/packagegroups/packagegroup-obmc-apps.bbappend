RDEPENDS_${PN}-inventory += "openpower-fru-vpd openpower-occ-control phosphor-cooling-type virtual/obmc-gpio-presence"
RDEPENDS_${PN}-fan-control += "swift-fan-watchdog"
RDEPENDS_${PN}-extras += "swift-power-supply-sync phosphor-webui"
