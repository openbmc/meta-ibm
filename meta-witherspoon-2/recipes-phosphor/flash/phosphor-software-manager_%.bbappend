BMC_RW_SIZE = "0x2000000"
