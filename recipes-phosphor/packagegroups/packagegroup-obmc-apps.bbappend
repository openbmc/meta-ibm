RDEPENDS_${PN}-logging += "ibm-logging nginx-prep-downgrade"
