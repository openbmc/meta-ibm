PACKAGECONFIG_remove_rainier = "adcsensor cpusensor exitairtempsensor \
                                fansensor intrusionsensor ipmbsensor \
                                mcutempsensor psusensor"
