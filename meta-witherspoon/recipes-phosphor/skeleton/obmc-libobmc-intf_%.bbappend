FILESEXTRAPATHS_prepend_swift := "${THISDIR}/${PN}/swift:"
FILESEXTRAPATHS_prepend_witherspoon := "${THISDIR}/${PN}/witherspoon:"
FILESEXTRAPATHS_prepend_witherspoon-128 := "${THISDIR}/${PN}/witherspoon:"
