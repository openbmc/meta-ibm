PACKAGECONFIG_append_witherspoon-128 = " host-dump-offload-pldm"
PACKAGECONFIG_append_rainier = " host-dump-offload-pldm"
