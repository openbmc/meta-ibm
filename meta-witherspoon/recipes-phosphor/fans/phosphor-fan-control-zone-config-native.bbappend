FILESEXTRAPATHS_prepend := "${THISDIR}/${MACHINE}-${PN}:"
FILESEXTRAPATHS_prepend_witherspoon-common := "${THISDIR}/witherspoon-${PN}:"
