EXTRA_OECONF_append_witherspoon-128 += " --enable-openpower-pel-extension"
