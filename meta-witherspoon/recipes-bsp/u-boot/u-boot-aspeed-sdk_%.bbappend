FILESEXTRAPATHS_prepend_witherspoon-tacoma := "${THISDIR}/${PN}:"
SRC_URI_append_witherspoon-tacoma = " file://tacoma.cfg"
